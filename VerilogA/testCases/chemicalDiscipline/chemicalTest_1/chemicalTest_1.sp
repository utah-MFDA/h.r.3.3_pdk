.hdl

*netlist

*probes

.probe
