*A simple valve test case

.hdl
