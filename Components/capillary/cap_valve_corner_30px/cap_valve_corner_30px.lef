
MACRO cap_valve_30px
  CLASS CORE ;
  ORIGIN  0 0 ;
  FOREIGN cap_valve_30px 0 0 ;
  SIZE 150 BY 150 ;
  SYMMETRY X Y ;
  SITE CoreSite ;
  OBS
    LAYER met1 ;
      RECT 30 30 120 120 ;
  END
  PROPERTY CatenaDesignType "deviceLevel" ;
END cap_valve_30px
